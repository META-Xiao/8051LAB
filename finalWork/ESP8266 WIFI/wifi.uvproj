# Keil uVision project wifi.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: wifi
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./: main.c
    ../lib/: ds18b20.c ds18b20.h esp8266.c esp8266.h sysinit.c sysinit.h uart.c uart.h
