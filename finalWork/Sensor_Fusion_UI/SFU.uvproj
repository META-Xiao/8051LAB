# Keil uVision project SFU.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: SFU
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./: config.h ds18b20.c main.c pcf8591.c ultra.c
    ../lib/: ds18b20.h oled7pin.c oled7pin.h oledfont.h pcf8591.h ultrasonic.h buzzer.c buzzer.h chart.c chart.h sysinit.c sysinit.h
