# Keil uVision project info.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: info
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./: font_cn.h main.c
    ../lib/: oled7pin.h sysinit.c sysinit.h oled7pin.c oledfont.h
