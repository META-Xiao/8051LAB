# Keil uVision project SF.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: SF
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib
  group Source Group 1
    ./: config.h main.c ds18b20.c pcf8591.c ultra.c boot_bmp.h
    ../lib/: sysinit.c sysinit.h oled7pin.c oled7pin.h oledfont.h buzzer.c buzzer.h
