# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: test
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: main.c
